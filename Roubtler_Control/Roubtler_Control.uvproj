# Keil uVision project Roubtler_Control.uvproj, settings and files
target mbed NXP LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Roubtler_Control
  AfterMake: fromelf --bin -o build\Roubtler_Control_LPC1768.bin build\Roubtler_Control.axf
  c flags: Optim=1
  c define: TARGET_LPC1768,  TARGET_M3,  TARGET_NXP,  TARGET_LPC176X,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M3,  ARM_MATH_CM3,
  c misc: --gnu
  c include: .;  MotorControl;  msg_util;  PID_Controller;  mbed;  mbed/TARGET_LPC1768;  mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD;  debugger;  QEI;
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/LPC1768.sct
  link misc: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/system_LPC17xx.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/startup_LPC17xx.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    msg_util/: frame_queue.c byte_queue.c crc_helper.c packet_finder.c msg_interface.cpp
    ./: main.cpp
    MotorControl/: MotorControl.cpp
    PID_Controller/: PID_Controller.cpp
    debugger/: debugger.cpp
    QEI/: QEI.cpp
