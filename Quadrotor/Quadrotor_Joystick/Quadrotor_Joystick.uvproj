# Keil uVision project Quadrotor_Joystick.uvproj, settings and files
target mbed NXP LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Quadrotor_Joystick
  AfterMake: fromelf --bin -o build\Quadrotor_Joystick_LPC1768.bin build\Quadrotor_Joystick.axf
  c flags: Optim=1
  c define: TARGET_LPC1768,  TARGET_M3,  TARGET_NXP,  TARGET_LPC176X,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M3,  ARM_MATH_CM3,
  c misc: --gnu
  c include: .;  msg_util;  mbed;  mbed/TARGET_LPC1768;  mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD;  MPU6050;  BLDC_Control;  IMU_MPU6050;  PID_BLDC_Control;
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/LPC1768.sct
  link misc: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/system_LPC17xx.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/startup_LPC17xx.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    msg_util/: frame_queue.c byte_queue.c crc_helper.c packet_finder.c msg_interface.cpp
    ./: main.cpp
    MPU6050/: MPU6050.cpp
    BLDC_Control/: BLDC_Control.cpp
    IMU_MPU6050/: IMU_MPU6050.cpp
    PID_BLDC_Control/: PID_BLDC_Control.cpp
